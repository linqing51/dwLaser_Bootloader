# Keil uVision project dwLaser_Bootloader.uvprojx, settings and files
target dwLaser_Bootloader (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: dwLaser_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/DSP/Include;../../dwLaser_Application/MCU_Application/lib;../Bootloader;../../dwLaser_Application/MCU_Application/sPlc;../../dwLaser_Application/MCU_Application/sPlcPort;../../dwLaser_Application/MCU_Application/deviceInfo;../../dwLaser_Application/MCU_Application/dcHmi;../../dwLaser_Application/MCU_Application/MainApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Bootload
    ../Bootloader/: bootLoader.c flash_if.c
    ../../dwLaser_Application/MCU_Application/lib/: libcrc.c
  group DeviceInfo
    ../../dwLaser_Application/MCU_Application/deviceInfo/: deviceConfig.c
software components: CMSIS:CORE 4.3.0
